SRCREV = "b7d116f385b6a990a4cc4ca633477345cb142969"

RDEPENDS:${PN} += " \
    python3-ruamel-yaml \
    python3-anytree \
    python3-six \
    python3-pyyaml \
    "
